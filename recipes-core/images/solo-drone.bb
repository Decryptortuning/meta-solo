SUMMARY = "3DR Solo drone image (alias target)"

PROVIDES += "solo_drone"

require recipes-core/images/3dr-solo.bb
