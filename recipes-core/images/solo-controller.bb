SUMMARY = "3DR Solo controller image (alias target)"

PROVIDES += "solo_controller"

require recipes-core/images/3dr-controller.bb
